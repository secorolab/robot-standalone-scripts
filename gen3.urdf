Commit message: added calib offsets for transformation matrices

File: gen3.urdf (robot description, URDF)
Before this commit: robot gen3_, 31 links, 30 joints
Links:
- link gen3_bracelet_link: mass 0.364 -> 0.5
